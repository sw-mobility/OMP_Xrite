ROS_BUILD_DEPENDS += " \
    generate-parameter-library-py-native \
"

ROS_EXEC_DEPENDS += " \
    generate-parameter-library-py \
"