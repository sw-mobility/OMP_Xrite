DEPENDS += " rosidl-adapter rosidl-default-generators rosidl-default-runtime"
DEPENDS += " rosidl-adapter-native rosidl-default-generators-native rosidl-default-runtime-native"
